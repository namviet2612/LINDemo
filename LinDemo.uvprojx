# Keil uVision project LinDemo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LinDemo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: ..\LinDemo
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c
  group lin_drv
    ./: lin.c
software components: CMSIS:CORE 4.3.0, Device:STM32Cube LL:COMMON 1.9.0, Device:STM32Cube LL:PWR 1.9.0, Device:STM32Cube LL:RCC 1.9.0, Device:STM32Cube LL:USART 1.9.0, Device:STM32Cube LL:UTILS 1.9.0, Device:Startup 1.0.0
